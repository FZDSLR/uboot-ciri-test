## mt8188_ciri_defconfig
```kconfig
#include <configs/mt8188.config>

CONFIG_DEFAULT_DEVICE_TREE="mediatek/mt8188-geralt-ciri-sku0"
CONFIG_IDENT_STRING="mt8188-geralt-ciri"
```
